## app/tests/dummy/testcase.yaml
```yaml
tests:
  dummy.pass:
    build_only: false
    platform_allow:
      - native_sim
    integration_platforms:
      - native_sim
    tags: unit_test
```
